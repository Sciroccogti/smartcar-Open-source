# IAR project Terminator_v1.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MK66F18; ARM_MATH_CM4
  ICCARM.CCIncludePath2: FILE_H; LIB; LIB\Kinetis; LIB\CMSIS; LIB\CMSIS\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Terminator_v1.0.out
  ILINK.IlinkIcfFile: CONFIG\Kinetis K66FN2M.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group APP
    FILE_C/: Attitude_Calculation.c main.c RouteLoad.c System_UI.c SystemControl.c Terminator.c Wifi.c
  group LIB
    FILE_C/: CommunicateDriver.c DisPlayDeviceDriver.c FLASH.c ImageSensorDriver.c KeyBoardDriver.c ProjectMath.c PulseCollectDriver.c SoftIIC.c TimerEventDriver.c
    FILE_H/: CommunicateDriver.h DisPlayDeviceDriver.h FLASH.h ImageSensorDriver.h KeyBoardDriver.h ProjectMath.h PulseCollectDriver.h SoftIIC.h TimerEventDriver.h
  group START
    FILE_C/: StartupC_K6X.c StartupS_K6X.s
