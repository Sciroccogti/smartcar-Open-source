<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FN15_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FN15_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FX15_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FX15_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DZ10_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DZ10_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\MK60_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\MK60_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Inc\PORT_cfg.h</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_ASCII.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_BMP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_computer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\vcan_img2sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_OV7725_Eagle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\vcan_sd_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\VCAN_UI_VAR.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\bsp_global_var.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\bsp_infrared.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\inc\bsp_macro.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\bsp_my_oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\bsp_oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\flash_param.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\I2C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\picture_deal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\scope.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\ui_debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\ui_debug_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\src\ui_setpage.c</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\inc\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_sdhc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_usb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\IAR\startup_MK60DZ10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\IAR\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\vectors.c</name>
    </file>
  </group>
  <group>
    <name>Control</name>
    <file>
      <name>$PROJ_DIR$\..\..\Control\direction.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Control\direction.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Control\speed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Control\speed.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Control\upstand.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Control\upstand.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>CMSIS</name>
    </group>
    <group>
      <name>FatFs</name>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\FatFs\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\FatFs\ff.c</name>
      </file>
    </group>
    <group>
      <name>USB</name>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\USB\USB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\USB\USB_CDC.c</name>
      </file>
    </group>
  </group>
</project>


