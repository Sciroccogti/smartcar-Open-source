# IAR project DLSZ.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\A_DLSZ; ..\..\A_DLSZ\Inc; ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DLSZ.bin
  ILINK.IlinkOutputFile: A_DLSZ.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\Acar; ..\..\Acar\Inc; ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Acar.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group A_DLSZ_7-11
    ../../A_DLSZ/: control.c huiche.c img_process.c move.c special.c system_init.c time_distance.c
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
    ../../A_DLSZ/: z_test.c
  group Board
    ../../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ILI9325.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
  group Other
    ../../A_DLSZ/: display.c elec_netic.c function.c interrupt.c
